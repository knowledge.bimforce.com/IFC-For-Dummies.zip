Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2018-10-11T11:18:05
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180328_1600(x64) - Exporter 19.1.0.0 - Alternate UI 19.1.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 11 11:18:05 2018 * Host: DESKTOP-FDA31SE * Database: C:\Users\marti\AppData\Local\Temp\{0B5F24C8-62CD-4DE3-A07D-262C04EFA5C1}\ifc * Database version: 5507 * Database creation date: Thu Oct 11 11:18:04 2018 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 11 11:18:05 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 11 11:18:05 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm

# IfcBuilding, Building Name
LongName: Building Name
Pset_ProductRequirements - Category: Project Information
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey: Level:8mm Head, T.O. Fnd. Wall
In: Building Name
LongName: T.O. Fnd. Wall; Elevation: -300 mm
Pset_ProductRequirements - Name: T.O. Fnd. Wall; Category: Levels
Pset_AirSideSystemInformation - Name: T.O. Fnd. Wall

# IfcBuildingElementProxy: Curved, Curved:Curved:317217
In: T.O. Fnd. Wall
Type - Pset_BuildingElementProxyCommon - Reference: Curved
Type - Pset_ProductRequirements - Category: Generic Models
Type - Pset_QuantityTakeOff - Reference: Curved
Pset_BuildingElementProxyCommon - sets with these values: 2
